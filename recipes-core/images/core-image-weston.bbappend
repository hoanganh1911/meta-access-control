IMAGE_INSTALL:append = " gstreamer1.0 gstreamer1.0-plugins-good gstreamer1.0-plugins-bad v4l-utils wayland weston"
